File: RCP Pi Hat.kicad_sch (KiCad schematic)
At the start: 21 parts, among them J1 Debug Pins, U3 AMS1117-3.3

Commit message: V20240220
Other:
- moved on the sheet: C1, C?, R1, TP3, U1, U2
